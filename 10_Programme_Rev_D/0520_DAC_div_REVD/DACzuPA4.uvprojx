# Keil uVision project DACzuPA4.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: DACzuPA4 +hex
  c flags: Optim=1 oTime=1 OneElfS=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: DACzuPA4.c TouchP0P1.lib
  group Weitere_Muster_Prog
    ./: DACTreppe.c DACTreppe_dual.c DACzuPA4_original.c DAC_Sin_Cos.c DAC_Dualmode.c DAC_DC_Noise.c DAC_DC_Noise_Strukturen.c DAC_DC_Noise_Strukturen_Funktion.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/Device/StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_dac.c stm32f10x_dma.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.1.0/RTE_Driver/: DMA_STM32F10x.c GPIO_STM32F10x.c
    RTE/Device/STM32F107VC/: RTE_Device.h startup_stm32f10x_cl.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 4.1.0, Device:DMA 1.01.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:DAC 3.5.0, Device:StdPeriph Drivers:DMA 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0
