# Keil uVision project MCB32_BME280.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: MCB32_I2C +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: USE_STDPERIPH_DRIVER
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: BME280_DEMO.c i2c.c delays_cz.c TouchP0P1.lib
    ./I2C_BME280/: bme280_CZ.c
  group Doku_and_other_Files
    ./I2C_BME280/: bme280_CZ.c bme280_CZ.h bme280_defs_CZ.h BME280_I2C.c
    ./printf_embedded/: my_printf.c
software components: CMSIS:CORE 3.20.0, Device:GPIO 1.01.0, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
