# Keil uVision project 0503_Bitman3_Einzelblinker_Funk.uvprojx, settings and files
target 0503_Bitman3 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: P0toP1 +hex
  c flags: Optim=1 OneElfS=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: 0503_Bitman3_Einzelblinker_Funk.c TouchP0P1.lib
