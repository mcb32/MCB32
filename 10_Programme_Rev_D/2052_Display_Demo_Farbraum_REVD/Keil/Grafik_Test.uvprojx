# Keil uVision project Grafik_Test.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Grafik_DEMO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: grafikfunkionen_5.c TouchP0P1.lib
  group ::Device
    RTE/Device/STM32F107VC/: RTE_Device.h startup_stm32f10x_cl.s system_stm32f10x.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
