# Keil uVision project 1440_TicTac_Toe.uvprojx, settings and files
target 1440_TicTac_Toe (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: P0toP1 +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: startup_stm32f10x_cl.s TouchP0P1.lib 1440_TicTac_Toe.c
software components: CMSIS:CORE 5.4.0, Device:Startup 1.0.0
