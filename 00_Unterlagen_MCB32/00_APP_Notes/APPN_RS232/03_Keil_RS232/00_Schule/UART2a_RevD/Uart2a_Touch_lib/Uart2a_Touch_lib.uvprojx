# Keil uVision project Uart2a_Touch_lib.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.1.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Uart2a_Touch_lib +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: TouchP0P1.lib USART2_Touch_Lib.c
  group Diverse_USART_Progr
    ./: uart2a_Funktion_init.c USART2_Touch_Lib.c USART2a.c Serial1.c Serial2.c Serial4.c Ser_Bsp2.c
  group ::Device
    RTE/Device/STM32F107VC/: RTE_Device.h startup_stm32f10x_cl.s system_stm32f10x.c
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
