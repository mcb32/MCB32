# Keil uVision project Project.uvprojx, settings and files
target ET-STM32F-ARM-KIT (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MCB32_UART_Demo +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER, STM32F10X_CL, USE_STM32F_ARM_KIT
  c include: ..\..\Project;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc;..\..\Libraries\CMSIS\Core\CM3;..\..\Libraries\STM32_ETH_Driver\inc;..\..\Libraries\STM32_USB-FS-Device_Driver\inc;..\..\efsl\inc;..\..\efsl\inc\interfaces;..\..\uip;..\..\usb_msd\inc;..\..\Utilities
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../: main.c stm32f10x_it.c
  group StdPeriph_Driver
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: stm32f10x_spi.c misc.c stm32f10x_flash.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rtc.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_fsmc.c stm32f10x_bkp.c
  group CMSIS
    ../../Libraries/CMSIS/Core/CM3/: core_cm3.c system_stm32f10x.c
  group RVMDK
    ../../Libraries/CMSIS/Core/CM3/startup/arm/: startup_stm32f10x_cl.s
  group Doc
    ./: readme.txt
  group ett_board
    ../../Utilities/: et_stm32f_arm_kit.c et_stm32f_arm_kit_i2c.c et_stm32f_arm_kit_lcd.c et_stm32f_arm_kit_uart.c
    ../: et_stm32f_arm_kit_glcd.c
