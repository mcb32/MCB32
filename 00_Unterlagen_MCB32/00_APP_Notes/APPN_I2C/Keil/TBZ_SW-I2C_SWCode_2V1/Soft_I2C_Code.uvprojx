# Keil uVision project Soft_I2C_Code.uvprojx, settings and files
target Soft_I2C (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: Soft_I2C +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: main.c sht3x.c PCF8574x.c i2c_hal.c system.c TouchP0P1.lib
  group Documents
    ./Documents/: Readme_I2C_SW.txt
  group ::Device
    RTE/Device/STM32F107VC/: RTE_Device.h startup_stm32f10x_cl.s system_stm32f10x.c
software components: CMSIS:CORE 3.20.0, Device:Startup 1.0.0
