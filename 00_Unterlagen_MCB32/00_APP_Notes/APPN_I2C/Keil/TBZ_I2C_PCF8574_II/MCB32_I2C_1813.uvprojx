# Keil uVision project MCB32_I2C_1813.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: STM32F107VC STMicroelectronics
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(72000000) ELITTLE
  output: MCB32_I2C_1813 +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: MCB32_I2C.c i2c.c delays_cz.c TouchP0P1.lib MCB32_I2C_V0.c MCB32_I2C_V161804A.c
  group ::Device
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/Device/StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_rcc.c
    C:/Keil_v5/ARM/PACK/Keil/STM32F1xx_DFP/1.0.5/RTE_Driver/: GPIO_STM32F10x.c
    RTE/Device/STM32F107VC/: RTE_Device.h startup_stm32f10x_cl.s stm32f10x_conf.h system_stm32f10x.c
software components: CMSIS:CORE 5.0.1, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:I2C 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0
