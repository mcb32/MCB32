# Keil uVision project 2051_Display_ADDA_IRQ-Uebung.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: TouchP0P1Test +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Source Group 1
    ./: ADDA_IRQ-Uebung_poti.c 2051_Display_ADDA_IRQ-Uebung.c TouchP0P1.lib
software components: CMSIS:CORE 3.40.0, Device:Startup 1.0.0
